# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template
  c flags: Optim=1
  c include: .\include;.\src\init;.\src\ccdebug\inlcude;.\src\libstm32\cmsis;.\src\libstm32\inc;.\src\ucosii\src;.\src\ucosii\port;.\src\task;.\src\HARDWARE\SRAM;.\src\HARDWARE\TIMER;.\src\HARDWARE\USART;.\src\HARDWARE\VS10XX;.\src\mem;.\src\collect\include;.\src\SYSTEM;.\src\SYSTEM\sys;.\src\SYSTEM\delay;.\src\HARDWARE\W5500;.\src\Internet\httpServer;.\src\Internet\PORT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group libstm32
    ./src/libstm32/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ./src/libstm32/cmsis/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group init
    ./src/init/: main.c stm32f10x_it.c wav.c
  group HARDWARE
    ./src/HARDWARE/SRAM/: sram.c
    ./src/HARDWARE/TIMER/: timerx.c
    ./src/HARDWARE/USART/: debug_usart.c
    ./src/HARDWARE/W5500/: w5500_port.c w5500_core.c w5500_socket.c
  group ucosii
    ./src/ucosii/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./src/ucosii/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group TASK
    ./src/task/: task_startup.c task_socket.c task_tcpserver.c
  group MEM
    ./src/mem/: lib_mem.c
  group Collect
    ./src/collect/: array.c common.c deque.c hashset.c hashtable.c list.c queue.c slist.c stack.c treeset.c treetable.c
  group SYSTEM
    ./src/SYSTEM/sys/: mysys.c
    ./src/SYSTEM/delay/: delay.c
  group CCDEBUG
    ./src/ccdebug/: ccdebug_port.c
  group HTTP
    ./src/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
  group Socket
    ./src/Internet/PORT/: socket_port.c
